# Keil uVision project Progect.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Progect +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\inc;..\Libraries\src;..\Startup;..\User;..\MQTT;..\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c stm32f10x_it.c System.c delay.c usart.c gpio.c iwdg.c timer.c stmflash.c flash_helper.c BufferManage.c LoopList.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Libraries
    ../Libraries/src/: misc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_bkp.c
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
